## config/boards/shields/Numpadv1/Kconfig.defconfig
```kconfig
if SHIELD_NUMPADV1

    config ZMK_KEYBOARD_NAME
        default "numpadv1"

endif
```
